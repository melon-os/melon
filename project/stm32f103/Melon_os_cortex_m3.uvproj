# Keil uVision project Melon_os_cortex_m3.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Melon_os_cortex_m3 +hex
  c flags: wLevel=2
  c include: ..\..\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../../app/: demo.c
  group boot
    ../../boot/arm/cortex_m3/stm32f103/: STM32F10x.s
  group arch
    ../../arch/arm/cortex_m3/stm32f103/: os_cpu.c
  group kernel
    ../../kernel/: os_core.c os_task.c os_mutex.c os_mailbox.c os_mem.c os_timer.c
  group driver
    ../../driver/: ad.c clock.c i2c.c lcd.c lcd_char.c led.c serial.c temperature.c speaker.c
  group init
    ../../init/: main.c
  group lib
    ../../lib/: common_func.c
    ../../lib/arm/cortex_m3/stm32f103/: STM32F10xR.LIB
  group include
    ../../include/: common_func.h
    ../../include/melon/: melon.h os_core.h os_task.h os_mutex.h melon_cfg.h
    ../../include/arch/: os_cpu.h
